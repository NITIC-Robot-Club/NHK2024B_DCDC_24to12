# Repository NITIC-Robot-Club/NHK2024B_DCDC_24to12

File README.md:

# 24V->12V降圧DCDC基板
> 茨城高専BチームR1(高専ロボコン2024)に搭載された降圧DCDC基板
> ROHM製 BD9F800MUX-Zを使用

## 概観
**スケッチ**

**実体配線**

**実装した図**

## 目的
- 24V駆動電源から12V 8Aを生成し、12Vを用いる制御機器に分配する

## 仕様
- **BD9F800MUX-Z**
	- [データシート](https://fscdn.rohm.com/jp/products/databook/datasheet/ic/power/switching_regulator/bd9f800mux-j.pdf?_fsi=rojoN0SD)
	- $F_{osc}$ = 600khz
	- $V_{max}$ = 28V
	
- ヒューズ破壊式逆接保護
	- SBD: [BR310_R1_00001](https://www.digikey.jp/short/h203d347)

## KiCad design DCDC_24to12.kicad_pcb

Parts:
C1, C3: 0.1uF; C_0805_2012Metric
C2: 2.2uF; C_0805_2012Metric
C4, C5: 10uF; C_0805_2012Metric
C6: 47uF; C_1206_3216Metric
C7: 22uF; C_0805_2012Metric
D1: D_Schottky; D_SMB
D2, D3, D4: LED; LED_0603_1608Metric
F1: 10A; FUSE_3557-2
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_Via
J1: Power_IN; AMASS_XT60PW-M_1x02_P7.20mm_Horizontal
J2: Power_OUT; AMASS_XT60-F_1x02_P7.20mm_Vertical
L1: 3.3uH; SRP1245A
R1: 10R; R_0805_2012Metric
R2, R8, R10: 10k; R_0805_2012Metric
R3: 100k; R_0805_2012Metric
R4: 47k; R_0805_2012Metric
R5, R9: 1k; R_0805_2012Metric
R6: 470R; R_0805_2012Metric
R7: 3k3; R_0805_2012Metric
U1: BD9F800MUX-ZE2; BD9F800MUX

Connections:
+12V: C6.1, C7.1, D4.2 (A), J2.2, L1.2, R1.1, R4.2
+BATT: C3.1, C4.1, C5.1, D1.1 (K), D2.2 (A), F1.1, R3.1, U1.8 (VIN), U1.11 (EN)
BOOT: C1.1, U1.1 (BOOT)
FB: R6.1, R7.1, U1.5 (FB)
FREQ: R2.1, U1.4 (FREQ)
GND: C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, D1.2 (A), J1.1, J2.1, R7.2, R8.2, R9.2, R10.2, U1.7 (GND), U1.10 (PGND)
unnamed: D2.1 (K), R8.1
unnamed: D3.1 (K), R9.1
unnamed: D4.1 (K), R10.1
unnamed: F1.2, J1.2
unnamed: R4.1, R5.2
unnamed: R5.1, R6.2
unnamed: R1.2, U1.3 (VOUT)
PGD: R3.2, U1.2 (PGD)
SW: C1.2, L1.1, U1.9 (SW)
VREG: C2.2, D3.2 (A), R2.2, U1.6 (VREG)

Notes on the sheet:
f = 600kHz, +BATT = 24V, Vout = 12V
飽和電流11A以上

Board: 2 copper layers, 75.0 x 74.4 mm, 30 parts (0 on the bottom side), 16 nets.

## Commit log

2024-07-08 いにしゃる こみっちょ
2024-07-08 抵抗値とか修正
2024-07-08 LED追加したり
2024-07-09 PGOODを+BATTで吊った
2024-07-09 ローカルなライブラリ追加
2024-07-09 逆接防止ショットキーバリアダイオード
2024-07-09 C_VREG選定完了
2024-07-09 逆接保護回路変更 損失抑えver.
2024-07-09 ヒューズ追加
2024-07-09 SBDフットプリント割り当て、PCB更新
2024-07-09 XT60をヨコに変更、ピン順序修正
2024-07-10 2x25pinMILコネクタ対応
2024-07-11 あれこれ
2024-07-11 MILコネクタばいばい
2024-07-11 コイル下のベタぬいた
2024-07-11 GNDベタ回り込み回避
2024-07-12 すごい修正
2024-07-12 インダクタをF面に戻した
2024-07-12 インダクタ回り修正
2024-07-12 基板サイズやや縮小
2024-07-12 XT60とヒューズの足元にマスク追加
2024-07-12 外寸書いた
2024-07-12 GNDベタやや拡大
2024-07-12 GNDベタすごく拡大
2024-07-12 配線微調整、外形フィレット
2024-07-12 XT60固定穴のGNDベタ消去
2024-07-12 穴追加 場所がねぇ
2024-07-12 null null したりどみ追加
2024-07-12 ベタ塗りなおし忘れ
2024-07-13 ビアへの配線を明示的にした
2024-07-13 BOM作成
2024-07-13 インダクタ上のビアとキープアウトを改善
2024-07-13 FB抵抗のGNDビア追加
2024-07-15 配置変更案 詳細未設定
2024-07-15 穴消したりいろいろ修正したり
2024-07-15 制御へのGNDにビア追加
2024-07-15 LED周りGNDビア改善（改悪の可能性もある）
2024-07-15 ノーテーション改善
2024-07-15 ビアボー
2024-07-15 シルクはビアより優先されます
2024-07-15 謎ミット
2024-07-15 フィレット
2024-07-16 素子まわりGNDベタ埋めた
2024-07-16 出力付近のGND配線太さ確保
2024-07-17 やや見た目改善
2024-07-17 pdf作成
2024-07-17 がばーzip
2024-07-17 インダクタ回りベタ整形
2024-07-17 がばー2
2024-07-20 ノーテーション変更の反映
2024-07-20 出力コネクタをタテにした
2024-07-20 だいぶ小型化
2024-07-20 外形とか配線とかビアとか整頓
2024-07-20 出力マスクでのGNDと+12V同時露出解決
2024-07-20 12V直下のベタを実線化
2024-07-23 出力コンデンサ位置修正
2024-07-24 なんか変更 prlだけ
2024-07-24 フィードバック抵抗上下逆だったので修正
2024-07-24 再アノテーション
2024-07-24 抵抗配置修正、シルク調整
2024-07-26 外形とベタとりあえず拡大
2024-07-26 外形位置修正、ビア削除など
2024-07-26 FREQにラベル貼った
2024-07-26 抵抗の位置いろいろ変更 配線済み
2024-07-27 GND回り込み経路を修正
2024-07-27 4層になりました
2024-07-27 集合体恐怖症絶対ビビらせるビア
2024-07-27 IC直下でGNDとPGNDが直結する問題を解決
2024-07-27 ビア微調整
2024-07-27 しーたけ、4層やめるってよ
2024-07-29 GNDベタレジストはがし25*25
2024-07-29 シルク変更、外形フィレット
2024-07-29 穴追加 4隅になりました
2024-07-30 ヘイロー追加
2024-07-30 ヘイロー基板に載せるマン
2024-07-30 見た目調整
2024-07-30 PDF更新
2024-07-30 gitignore変更 ガーバーの置き場所とか
2024-07-30 ガーバー置き場が変わったりgitignoreが変わったりしたやつ
2024-07-30 基板端GNDビア追加
2024-07-31 ガバーでました
2024-08-01 製造番号指定追加
2024-08-10 LED識別用シルク追加
2024-08-13 BOM更新
2024-12-16 ADD: 仕様と目的など追加
2024-12-16 NEW: READMEのための写真
2024-12-16 図とかつけてみた
2024-12-16 ADD: READMEの写真for仕様
2024-12-16 ADD: 仕様書き足し
